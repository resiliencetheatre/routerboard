## Config.in
```kconfig
source "$BR2_EXTERNAL_communit_PATH/package/libnitrokey/Config.in"
source "$BR2_EXTERNAL_communit_PATH/package/nkmacsec/Config.in"
```
